LR_IROM1 0x08000000 0x00020000 {
  ER_IROM1 0x08000000 0x00020000 {
   obj\jump.o (.vectors, +First)
   .ANY (+RO)
  }
  RW_IRAM1 0x24000000 0x00080000 {
   .ANY (+RW +ZI)
  }
}
