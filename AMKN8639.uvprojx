# Keil uVision project AMKN8639.uvprojx, settings and files
target AMKN8639 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: AMKN8639_APP +hex
  AfterMake: fromelf --bin --output .\output\bin\AMKN8639_APP.bin .\output\AMKN8639_APP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: AMKN8639_TYPE
  c include: ..;..\..\source;..\..\Config;..\..\FatFS\source;..\..\init;..\..\Libraries;.\Config;..\..\driver;..\..\libapp;..\..\FreeRTOS\include;..\..\FreeRTOS;..\..\FreeRTOS_App;..\..\lwip-2.1.3\src\include\lwip;..\..\lwip-2.1.3\src\include;..\..\lwip-2.1.3\src\core\ipv4;..\..\lwip-2.1.3\src\core;..\..\lwip-2.1.3\src;..\..\lwip-2.1.3\src\netif;..\..\lwip-2.1.3\src\api;..\..\lwip-2.1.3;..\..\lwip-2.1.3\system;..\..\lwip-2.1.3\src\core\ipv6;..\..\lwip-2.1.3\app;..\..\lwip-2.1.3\arch;..\..\CANOpen\inc;..\..\CANOpen\dictionary;..\..\CANOpen\canopen_app;..\..\CANOpen\inc\stm32;..\..\source\fonts;..\..\source\image
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\config\STM32H743XX_FlashIAP.scat
  link misc: --entry ResetHndlr
  group config
    ../../config/: const.h config.h can_config.h debug_config.h test_config.h modbus_config.h iap_config.h irq_priority_config.h product_config.h dma_config.h modbus_slave_config.h mdma_config.h
    ./config/: AMKN8639_Config.h AMKN8639_IOConfig.h
  group Source
    ../../source/: ISRHook.c ISRHook.h main.c TaskFile.c TaskLWIP.c UserVars.c TaskEventCtrl.c TaskInputData.c TaskOutputData.c TaskProcessData.c TaskUserCtrl.c TaskZqxyCtrl.c comfun.c user_app.c user_app.h user_adcapp.c user_canapp.c user_deviceapp.c user_fclkapp.c user_ioapp.c user_netwifiapp.c user_testapp.c user_uartapp.c user_usbapp.c user_pwmapp.c TaskUserApp1.c TaskCANOpen.c user_inputdata.c TaskModbus.c ConfigPara.h UserVars.h user_data.h user_config.h user_const.h TaskLCD.c vars.c vars.h TaskTest.c
    ../../source/fonts/: asc12.c asc16.c asc24.c asc32.c fonts.h hz12.c hz16.c hz24.c hz32.c
    ../../source/Image/: Image.c
  group libapp
    ../../libapp/: adc_app.c can_app.c dac_app.c eeprom_app.c exti_app.c fclk_app.c io_app.c IRQHandler.c libapp.c LibAppVars.c LibOSHook.c modbus_app.c net_app.c pwm_app.c rtc_app.c spiflash_app.c tim_app.c uart_app.c LibAppVars.h LibOSHook.h dma_app.c fatfs_app.c file_app.c i2c_app.c spi_app.c usb_app.c modbus_slave_app.c dma2d_app.c ltdc_app.c sdram_app.c at.c jpeg_app.c lptim_app.c mdma_app.c tftp.c qspi_app.c
  group driver
    ../../driver/: device_app.c device_app.h device_exfun.h
    ../../driver/wifi/: wifi.c wifi.h wifi_app.c wifi_app.h wifi_config.h
    ../../driver/ft5xxx/: ft5xxx.c ft5xxx_app.c ft5xxx_config.h
    ../../driver/i2c_io/: i2c_io.c
  group Libraries
    ../../Libraries/: adc.h at45dbxx.h bkp.h can.h crc.h dac.h delay.h eeprom.h exti.h flash.h fsmc.h gpio.h i2c.h iap.h iwdg.h modbus.h net.h NFlash.h rtc.h sd.h spi.h subfun.h sysint.h timer.h Uart.h USBDevice.h USBHost.h W25Qxx.h AMKN.h ltdc.h dma2d.h jpeg.h mdma.h lptimer.h ipcc.h qspi.h sdram.h dma.h pwr.h lib_readme.txt STM32H743XX_V131_20260415.lib
  group init
    ../../init/: inita.s
    ../../init/freertos/: vectors_m7.s
  group fatfs
    ../../FatFS/source/: diskio.c ff.c ffunicode.c ffsystem.c diskio.h ff.h integer.h ffconf.h
  group lwip
    ../../lwip-2.1.3/: lwip.c lwipopts.h
    ../../lwip-2.1.3/arch/: ethernetif.h sys_arch.h cc.h sys_arch.c ethernetif.c
  group readme
    ../../doc/: readme.txt
  group FreeRTOS
    ../../FreeRTOS/: heap_4.c list.c queue.c tasks.c event_groups.c timers.c
    ../../FreeRTOS/CM4/: port.c
  group FreeRTOS_App
    ../../FreeRTOS_App/: app_cfg.h FreeRTOS_APP.c OSVars.h OSVars.c FreeRTOSConfig.h
  group canopen
    ../../CANopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../../CANOpen/hardware/: canopen_config.h
    ../../CANOpen/dictionary/: Master.c Master.h
  group canopen_app
    ../../CANOpen/canopen_app/: canopen_app.c canopen_app.h canopen_config.h timer3.c timer3.h
